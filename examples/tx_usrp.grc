options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 470.3e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/2/100
    stop: samp_rate/2
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '50'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    minoutbuf: '100000'
    tag: packet_len
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    minoutbuf: '100000'
    phase_inc: (2 * math.pi * offset) / samp_rate
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_copy_cc_0
  id: lora_copy_cc
  parameters:
    len_tag_key: packet_len
    minoutbuf: '100000'
  states: {}
- name: lora_encode_0
  id: lora_encode
  parameters:
    code_rate: code_rate
    crc: 'False'
    header: header
    low_data_rate: ldr
    spreading_factor: spreading_factor
  states: {}
- name: lora_mod_0
  id: lora_mod
  parameters:
    spreading_factor: spreading_factor
    sync_word: '0x12'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Setting sample rate to the highest expected bandwidth enables the bandwidth to be changed on the fly via the resampler.
  states: {}
- name: note_2
  id: note
  parameters:
    note: Resample to the desired bandwidth.
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    minoutbuf: '1000000'
    nfilts: '32'
    rrate: samp_rate/bw
    type: ccf
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequency
    clock_rate: '0.0'
    dev_addr: '"type=b200"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_rotator_cc_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', lora_copy_cc_0, '0']
- [blocks_rotator_cc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_socket_pdu_0, pdus, lora_encode_0, in]
- [lora_copy_cc_0, '0', uhd_usrp_sink_0, '0']
- [lora_encode_0, out, lora_mod_0, in]
- [lora_mod_0, out, blocks_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
