options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: code_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: header
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: lora_mod_iq_sink.32iq
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: code_rate
    crc: 'True'
    header: header
    low_data_rate: ldr
    payload_len: '4'
    spreading_factor: spreading_factor
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: '1'
    crc: 'True'
    fft_factor: '2'
    fs_bw_ratio: '2'
    header: 'True'
    low_data_rate: ldr
    payload_len: '4'
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: spreading_factor
  states: {}
- name: lora_encode_0
  id: lora_encode
  parameters:
    code_rate: code_rate
    crc: 'False'
    header: header
    low_data_rate: ldr
    spreading_factor: spreading_factor
  states: {}
- name: lora_mod_0
  id: lora_mod
  parameters:
    spreading_factor: spreading_factor
    sync_word: '0x12'
  states: {}

connections:
- [blocks_socket_pdu_0, pdus, lora_encode_0, in]
- [blocks_throttle_0_0, '0', lora_demod_0, '0']
- [lora_decode_0, header, lora_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0, print_pdu]
- [lora_decode_0, out, blocks_socket_pdu_0_0, pdus]
- [lora_demod_0, out, lora_decode_0, in]
- [lora_encode_0, out, lora_mod_0, in]
- [lora_mod_0, '0', blocks_file_sink_0_0, '0']
- [lora_mod_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
