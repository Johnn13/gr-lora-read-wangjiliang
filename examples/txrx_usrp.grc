options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: code_rate
  id: variable
  parameters:
    value: '4'
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 919.75e6
  states: {}
- name: header
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: ldr
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: samp_rate/2/100
    stop: samp_rate/2
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '35'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3*1
  states: {}
- name: spreading_factor
  id: variable
  parameters:
    value: '8'
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '89'
    value: '35'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    minoutbuf: '100000'
    tag: packet_len
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (2 * math.pi * offset) / samp_rate
  states: {state: disabled}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: (2 * math.pi * offset) / samp_rate
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '1000'
    port: '52001'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52002'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: lora_copy_cc_0
  id: lora_copy_cc
  parameters:
    len_tag_key: packet_len
    minoutbuf: '100000'
  states: {}
- name: lora_decode_0
  id: lora_decode
  parameters:
    code_rate: code_rate
    crc: 'True'
    header: header
    low_data_rate: ldr
    payload_len: '4'
    spreading_factor: spreading_factor
  states: {}
- name: lora_demod_0
  id: lora_demod
  parameters:
    beta: '25.0'
    code_rate: code_rate
    crc: 'True'
    fft_factor: '2'
    fs_bw_ratio: '1'
    header: header
    low_data_rate: ldr
    payload_len: '4'
    peak_search_algorithm: '0'
    peak_search_phase_k: '4'
    spreading_factor: spreading_factor
  states: {}
- name: lora_encode_0
  id: lora_encode
  parameters:
    code_rate: code_rate
    crc: 'True'
    header: header
    low_data_rate: ldr
    spreading_factor: spreading_factor
  states: {}
- name: lora_mod_0
  id: lora_mod
  parameters:
    spreading_factor: spreading_factor
    sync_word: '0x12'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Setting sample rate to the highest expected bandwidth enables the bandwidth to be changed on the fly via the resampler.
  states: {}
- name: note_2
  id: note
  parameters:
    note: Resample to the desired bandwidth.
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: samp_rate/bw
    type: ccf
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_0_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: bw/samp_rate
    type: ccf
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: frequency
    clock_rate: '0.0'
    dev_addr: '"master_clock_rate=16e6"'
    dev_args: '""'
    gain0: tx_gain
    len_tag_name: packet_len
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: '"master_clock_rate=16e6"'
    gain0: rx_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_rotator_cc_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', lora_copy_cc_0, '0']
- [blocks_rotator_cc_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_rotator_cc_0_0, '0', pfb_arb_resampler_xxx_0_0, '0']
- [blocks_socket_pdu_0, pdus, lora_encode_0, in]
- [lora_copy_cc_0, '0', uhd_usrp_sink_0, '0']
- [lora_decode_0, header, lora_demod_0, header]
- [lora_decode_0, out, blocks_message_debug_0_0, print_pdu]
- [lora_decode_0, out, blocks_socket_pdu_0_0, pdus]
- [lora_demod_0, out, lora_decode_0, in]
- [lora_encode_0, out, lora_mod_0, in]
- [lora_mod_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [pfb_arb_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']
- [pfb_arb_resampler_xxx_0_0, '0', lora_demod_0, '0']
- [uhd_usrp_source_0, '0', blocks_rotator_cc_0_0, '0']
- [uhd_usrp_source_0, '0', lora_demod_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
